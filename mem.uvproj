# Keil uVision project mem.uvproj, settings and files
target Lab1 (5020028::V5.02 [Build 28]::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Lab1
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./src/: startup_LPC17xx.s
  group Source
    ./src/: system_LPC17xx.c utils.c rtx.c main_svc.c process.c usr_proc.c HAL.c uart_irq.c timer.c memory.c ipc.c system_proc.c iprocess.c irq.c unit_tests.c hot_keys.c uart_polling.c
